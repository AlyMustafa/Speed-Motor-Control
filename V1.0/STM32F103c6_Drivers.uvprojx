# Keil uVision project STM32F103c6_Drivers.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C6
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c STM32F103x6.h RCC.h Platform_Types.h NVIC.h PWM.h PWM.c EXTI.c GPIO.c TIM.c EXTI.h GPIO.h TIM.h LCD.c LCD.h UltraSonic.h UltraSonic.c Servo.h Servo.c dcmotor.c dcmotor.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
